## busybox/Config.in
```kconfig
if PACKAGE_busybox

source "package/feeds/bootrepo/busybox/config/Config.in"

endif
```
